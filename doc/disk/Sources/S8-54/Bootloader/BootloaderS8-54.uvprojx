# Keil uVision project BootloaderS8-54.uvprojx, settings and files
target BootloaderS8-54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootloaderS8-54
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER, STM32F437xx
  c include: ..\..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;.\src;.\src\libs;..\..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BootloaderS8-54.sct
  group FatFS
    ../../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h 00readme.txt
    ../../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
    ../../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c usbh_diskio.h
  group HAL
    ../../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hcd.h stm32f4xx_ll_usb.h stm32f4xx_hal_rcc.h stm32f4xx_hal_sram.h
    ../../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_gpio.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c
  group USBH
    ../../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group src
    ./src/: main.c globals.c globals.h main.h defines.h
  group libs
    ./src/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h system_stm32f4xx.c usbh_conf.c usbh_conf.h stm32f4xx_hal_msp.c
  group Display
    ./src/Display/: Display.c Display.h Painter.c Painter.h PainterC.h DisplayTypes.h Colors.c Colors.h PainterText.c PainterText.h
  group Display/fonts
    ./src/Display/font/: Font.c Font.h
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.c FlashDrive.h
  group Hardware
    ./src/Hardware/: FLASH.c FLASH.h Hardware.c Hardware.h FSMC.c FSMC.h Timer.c Timer.h
  group Panel
    ./src/Panel/: Controls.c Controls.h Panel.c Panel.h PanelFunctions.c
  group Settings
    ./src/Settings/: Settings.c Settings.h SettingsTypes.h
  group Utils
    ./src/Utils/: GlobalFunctions.c GlobalFunctions.h Math.c Math.h
