# Keil uVision project S8-54.uvprojx, settings and files
target S8-54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-54
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx
  c misc: --c99
  c include: ..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include\;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy\;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src\;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src\;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src\include;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\system;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src;src;src\EMUz80;src\libs;..\STM32Cube_FW_F4\Drivers\CMSIS\Include;.\src\Ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\S8-54.sct
  group HAL
    ../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_crc.c
  group USBD
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USBH
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group FatFS
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group LwIP
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c etharp.c ip4_frag.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c ip.c timeouts.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group libs
    ./src/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c usbd_cdc_interface.c usbd_cdc_interface.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h usbh_conf.c usbh_conf.h
  group src
    ./src/: defines.c defines.h Globals.c Globals.h Log.c Log.h main.c main.h main2.s Tables.c Tables.h
  group Data
    ./src/Data/: Data.c Data.h DataBuffer.c DataBuffer.h DataSettings.c DataSettings.h DataStorage.c DataStorage.h
  group Display
    ./src/Display/: Colors.c Colors.h Display.c Display.h DisplayPrimitives.c DisplayPrimitives.h DisplayTypes.h Grid.c Grid.h Math3D.c Math3D.h Painter.c Painter.h PainterC.h PainterMem.c PainterMem.h PainterText.c PainterText.h Symbols.h WelcomeScreen.c WelcomeScreen.h PainterData.c PainterData.h
  group Display/font
    ./src/Display/font/: Font.c Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Ethernet
    ./src/Ethernet/: Ethernet.c Ethernet.h TcpSocket.c TcpSocket.h app_ethernet.c app_ethernet.h ethernetif.c ethernetif.h lwipopts.h
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.c FlashDrive.h
  group FPGA
    ./src/FPGA/: FPGA.c FPGA.h FPGAExtensions.c FPGAExtensions.h FPGASettings.c FPGATypes.h FPGATypes.c
  group Hardware
    ./src/Hardware/: FLASH.c FLASH.h FSMC.c FSMC.h Hardware.c Hardware.h RAM.c RAM.h RTC.c RTC.h Sound.c Sound.h Timer.c Timer.h
  group Menu
    ./src/Menu/: FileManager.c FileManager.h Menu.c Menu.h MenuDrawing.c MenuDrawing.h MenuFunctions.c MenuFunctions.h MenuItems.h MenuItemsGraphics.c MenuItemsGraphics.h MenuItemsLogic.c MenuItemsLogic.h
  group Menu/Pages
    ./src/Menu/Pages/: Definition.c Definition.h HelpContent.c HelpContent.h HelpContentPages.h PageChannels.c PageCursors.c PageCursors.h PageDisplay.c PageDisplay.h PageMeasures.c PageTime.c PageTrig.c PageDebug.c PageMemory.c PageMemory.h PageService.c PageHelp.c PageHelp.h
  group Panel
    ./src/Panel/: Controls.c Controls.h Panel.c Panel.h PanelFunctions.h
  group SelfRecorder
    ./src/SelfRecorder/: SelfRecorder.c SelfRecorder.h
  group Settings
    ./src/Settings/: Settings.c Settings.h SettingsChannel.c SettingsChannel.h SettingsCursors.c SettingsCursors.h SettingsDebug.c SettingsDebug.h SettingsDisplay.c SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.c SettingsMemory.h SettingsService.c SettingsService.h SettingsTime.c SettingsTime.h SettingsTrig.h SettingsTypes.h
  group Utils
    ./src/Utils/: CreateTables.py Debug.c Debug.h Generator.c Generator.h GlobalFunctions.c GlobalFunctions.h Map.c Map.h Math.c Math.h Measures.c Measures.h ProcessingSignal.c ProcessingSignal.h Strings.c Strings.h TablesLog.h TablesWindow.h Dictionary.h Dictionary.c
  group VCP
    ./src/VCP/: VCP.c VCP.h
  group VCP/SCPI
    ./src/VCP/SCPI/: channelSCPI.c commonSCPI.c commonSCPI.h controlSCPI.c controlSCPI.h displaySCPI.c SCPI.c SCPI.h tbaseSCPI.c trigSCPI.c
