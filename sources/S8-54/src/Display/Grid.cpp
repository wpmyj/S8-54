#include "Grid.h"
#include "Globals.h"
#include "Settings/Settings.h"
#include "Menu/Menu.h"


//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
Grid grid;


//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
int Grid::Left(void)
{
    return (MenuIsMinimize() && MENU_IS_SHOWN ? 9 : 20) + meas.GetDeltaGridLeft();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::Right(void)
{
    return ((MenuIsMinimize() && MENU_IS_SHOWN) ? 9 : 20) + 280;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelBottom(void)
{
    return (sDisplay_IsSeparate()) ? (GRID_TOP + GRID_HEIGHT / 2) : FullBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelHeight(void)
{
    return (sDisplay_IsSeparate()) ? grid.FullHeight() / 2 : grid.FullHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::ChannelCenterHeight(void)
{
    return (GRID_TOP + grid.ChannelBottom()) / 2;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullBottom(void)
{
    return GRID_BOTTOM - meas.GetDeltaGridBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullHeight(void)
{
    return grid.FullBottom() - GRID_TOP;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::Width(void)
{
    return grid.Right() - grid.Left();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::FullCenterHeight(void)
{
    return (grid.FullBottom() + GRID_TOP) / 2;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::WidthInCells(void)
{
    return MENU_IS_SHOWN ? 10 : 14;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
float Grid::DeltaY(void)
{
    float delta = (grid.FullBottom() - GRID_TOP) / 10.0f;
    return sDisplay_IsSeparate() ? (delta / 2.0f) : delta;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
float Grid::DeltaX(void)
{
    float delta = (grid.Right() - grid.Left()) / 14.0f;
    return delta;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathTop(void)
{
    return grid.MathBottom() - grid.MathHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathHeight(void)
{
    if (FFT_ENABLED || FUNC_MODE_DRAW_SEPARATE)
    {
        return grid.FullHeight() / 2;
    }
    return grid.FullHeight();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::MathBottom(void)
{
    return grid.FullBottom();
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
int Grid::BottomMessages(void)
{
    int retValue = grid.FullBottom();
    if (MODE_WORK_ROM)
    {
        retValue -= 12;
    }
    else if (SHOW_MEASURES)
    {
        retValue = TOP_MEASURES;
    }
    return retValue - 12;;
}

//----------------------------------------------------------------------------------------------------------------------------------------------------
void Grid::CoordTrigLevel(int *left, int *top, int width)
{
    if (!SHOW_MEASURES || NUM_MEASURES < MN_6_1)
    {
        *left = (grid.Width() - width) / 2 + grid.Left();
        *top = BottomMessages() - 20;
    }
    else
    {
        *left = NUM_MEASURES_6_1 ? 100 : 130;
        *top = grid.FullBottom() - 32;
    }
}
